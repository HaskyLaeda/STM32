# IAR project Backup of STM32_Sample_C.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103xB ST STM32F103xB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: STM32F10X_MD
  ICCARM.CCIncludePath2: Applications; Config\CMSIS; Config\CMSIS\CM3\DeviceSupport\ST\STM32F10x; Config\Core; Source; ; FreeRTOS\portable; FreeRTOS\include; FreeRTOS; FatFS; FatFS\src; FatFS\src\option
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM32_SamplePrj_C.srec
  ILINK.IlinkOutputFile: STM32_SamplePrj_C.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: main.c main.h
  group Config/CMSIS
    Config/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/iar/: startup_stm32f10x_md.s
    Config/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group Config/Core
    Config/Core/: arm_common_tables.h arm_const_structs.h arm_math.h core_cm3.h core_cmFunc.h core_cmInstr.h
  group Source
    Source/: DataTypes.h font.h GlobalError.c GlobalError.h includes.h interrupts.cpp interrupts.h lcd.cpp lcd.h STM32F10xXX_SPI.cpp STM32F10xXX_SPI.h STM32F10xXX_USART.cpp STM32F10xXX_USART.h types.h UserConfig.cpp UserConfig.h
